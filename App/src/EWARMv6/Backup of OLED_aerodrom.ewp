# IAR project Backup of OLED_aerodrom.ewp, settings and files
configuration STM32F407IGT6 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\; ..\CMSIS\Device\ST\STM32F4xx\Include; ..\STM32F4xx_StdPeriph_Driver\inc; ..\STM32F4xx_StdPeriph_Driver; ..\IntmashLib; ..\OP.OLED.CM4; ..\Buttons; ..\Display; ..\Screens; ..\STM32F4xx_Intmash_Driver; ..\UserData
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OLED_EFICPU.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Buttons
    ../Buttons/: buttons.c Buttons_action.c
  group CMSIS
    ../CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Display
    ../Display/: display.c font_Luc_Cons_7pt.c font_Luc_Cons_9pt.c ssd1305.c
  group EWARMv6
    ../CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group IntmashLib
    ../IntmashLib/: crc16.c id.c ModbusMaster.c ModbusSlave.c
  group OP.OLED.CM4
    ../OP.OLED.CM4/: init.c LEDs.c main.c stm32f4xx_it.c
  group Screens
    ../Screens/: AjDataTypes.c Screens.c
  group StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group STM32F4xx_Intmash_Driver
    ../STM32F4xx_Intmash_Driver/: STM32F4xx_Intmash_Flash.c STM32F4xx_intmash_MBbasicCommands.c STM32F4xx_Intmash_USART.c
  group UserData
    ../UserData/: CalibrationData.c flashdata.c ModbusMasterConf.c ModbusSlaveConf.c ramdata.c Screen_data.c
